# Keil uVision project Blinky.uvprojx, settings and files
target Simulation (6070000::V6.7::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Blinky
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
software components: RTOS:Config 9.0.0, RTOS:Core 9.0.0, RTOS:Heap 9.0.0, RTOS:Timers 9.0.0, CMSIS:CORE 5.0.2, Device:Startup 1.0.1, Compiler:Event Recorder 1.1.0
