# Keil uVision project TZ_NonSecure.uvprojx, settings and files
target Virtual Hardware Target (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: TZ_NonSecure
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Secure
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\RTE\Device\ARMCM33_DSP_FP_TZ\ARMCM33_ac6.sct
  group Documentation
    ./: Abstract.txt
  group Secure Library
    ../Secure/Objects/: TZ_Secure_CMSE_Lib.o
    ../Secure/: library_nsc.h
  group Non-Secure Code
    ./: main_ns.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:Startup 2.1.0, RTOS:Config 10.6.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, Compiler:Event Recorder 1.5.1
