# IAR project RTOSDemo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x200
  General.HeapSize: 0x4
  ICCRX.CCDefines: DEBUG_BUILD
  ICCRX.CCDiagSuppress: Pa082, Pe1644, Pa050, Pa039
  ICCRX.CCIncludePath2: .; ..\Common\include; ..\..\Source\include; ..\..\Source\portable\IAR\RX600; include; ..\Common\ethernet\FreeTCPIP; webserver
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Blinky (RX, debug)
  as the first configuration, except:
  General.GenDataModel: 2
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: .; ..\Common\include; ..\..\Source\include; ..\..\Source\portable\IAR\RX600; include; webserver
configuration Debug-with-optimisation (RX, debug)
  as the first configuration, except:
  ICCRX.CCDefines: INCLUDE_HIGH_FREQUENCY_TIMER_TEST
  group (top)
    ./: HighFrequencyTimerTest.c IntQueueTimer.c main-blinky.c main-full.c ParTest.c RegTest.s uIP_Task.c
  group Common Demo Files
    ../Common/Minimal/: BlockQ.c blocktim.c death.c flash.c flop.c GenQTest.c integer.c IntQueue.c PollQ.c QPeek.c recmutex.c semtest.c
  group FreeRTOS Source
    ../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS Source/Portable Layer
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/RX600/: port.c port_asm.s
  group FreeTCPIP (based on uIP)
    ../Common/ethernet/FreeTCPIP/: psock.c timer.c uip.c uip_arp.c
  group FreeTCPIP (based on uIP)/webserver/Common
    ../Common/ethernet/FreeTCPIP/apps/httpd/: http-strings.c httpd-fs.c httpd.c
  group FreeTCPIP (based on uIP)/webserver/Port specific
    webserver/: EMAC.c httpd-cgi.c phy.c
  group Renesas Files
    Renesas-Files/: hwsetup.c
