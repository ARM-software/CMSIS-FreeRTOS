# IAR project RTOSDemo.ewp, settings and files
configuration Full (ARM, debug)
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCDiagSuppress: Pa082, Pe1644, Pa039, Pa050, pe191
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM3; ..\Common\include; Freescale_Code\common; Freescale_Code\cpu; Freescale_Code\drivers\uart; Freescale_Code\drivers\mcg; Freescale_Code\drivers\wdog; Freescale_Code\drivers\adc16; Freescale_Code\drivers\enet; ..\Common\ethernet\FreeTCPIP; webserver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Freescale_Code\common\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Blinky (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM3; ..\Common\include; Freescale_Code\common; Freescale_Code\cpu; Freescale_Code\drivers\uart; Freescale_Code\drivers\mcg; Freescale_Code\drivers\wdog; Freescale_Code\drivers\adc16
  ICCARM.CCOptLevel: 1
  group (top)
    ./: FreeRTOSConfig.h main-full.c main_blinky.c ParTest.c uIP_Task.c
  group Common_Demo_Files
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c GenQTest.c PollQ.c QPeek.c recmutex.c semtest.c TimerDemo.c
  group FreeRTOS_Source
    ../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/portable
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Freescale_Code/common
    Freescale_Code/common/: startup.c
  group Freescale_Code/cpu
    Freescale_Code/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group Freescale_Code/drivers/enet
    Freescale_Code/drivers/enet/: enet.c eth_phy.c mii.c
  group Freescale_Code/drivers/mcg
    Freescale_Code/drivers/mcg/: mcg.c
  group Freescale_Code/drivers/uart
    Freescale_Code/drivers/uart/: uart.c
  group Freescale_Code/drivers/wdog
    Freescale_Code/drivers/wdog/: wdog.c
  group FreeTCPIP (based on uIP)
    ../Common/ethernet/FreeTCPIP/: psock.c timer.c uip.c uip_arp.c
  group FreeTCPIP (based on uIP)/webserver/Common
    ../Common/ethernet/FreeTCPIP/apps/httpd/: http-strings.c httpd-fs.c httpd.c
  group FreeTCPIP (based on uIP)/webserver/Port specific
    webserver/: EMAC.c httpd-cgi.c
