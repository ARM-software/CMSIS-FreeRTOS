# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: IAR_ARMCM3_LM; PACK_STRUCT_END=
  ICCARM.CCDiagSuppress: pe550, pe144, pa039
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ; ..\Common\drivers\LuminaryMicro; ..\common\include; ..\..\source\include; webserver; ..\Common\ethernet\uIP\uip-1.0\uip
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: LM3Sxxxx.icf
  ILINK.IlinkAdditionalLibs: ..\Common\drivers\LuminaryMicro\IAR\driverlib.a; ..\Common\drivers\LuminaryMicro\IAR\grlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Demo files
    ../Common/Minimal/: BlockQ.c blocktim.c death.c EventGroupsDemo.c flash.c GenQTest.c integer.c IntQueue.c MessageBufferDemo.c PollQ.c QPeek.c QueueSet.c recmutex.c semtest.c StreamBufferDemo.c
    ./: IntQueueTimer.c main.c timertest.c
    ParTest/: ParTest.c
  group Library files
    ../Common/drivers/LuminaryMicro/IAR/: driverlib.a grlib.a
    ./: formike128x128x16.c osram128x64x4.c rit128x96x4.c
  group Scheduler files
    ../../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group System files
    ./: startup_ewarm.c
  group uIP files
    webserver/: emac.c http-strings.c httpd-cgi.c httpd-fs.c httpd.c uIP_Task.c
    ../Common/ethernet/uIP/uip-1.0/uip/: psock.c timer.c uip.c uip_arp.c
