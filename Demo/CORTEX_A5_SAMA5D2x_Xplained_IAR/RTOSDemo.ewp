# IAR project RTOSDemo.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Atmel ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: CONFIG_BOARD_SAMA5D2_XPLAINED; CONFIG_SOC_SAMA5D27; CONFIG_HAVE_TWI_ALTERNATE_CMD; LEDS_ON_J17; sram; TRACE_LEVEL=0; CONFIG_HAVE_PIO4
  ICCARM.CCDiagSuppress: Pa131, Pa039
  ICCARM.CCIncludePath2: .; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CA5_No_GIC; ..\Common\include; Full_Demo; AtmelFiles\target\sama5d2; AtmelFiles\target\sama5d2\pio; AtmelFiles\target\sama5d2\component; AtmelFiles\utils; AtmelFiles\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: sama5d3x; sram; __ASSEMBLY__
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: AtmelFiles\target\sama5d2\toolchain\iar\sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group (top)
    ./: cstartup_with_FreeRTOS_vectors.s FreeRTOS_tick_config.c FreeRTOSConfig.h LEDs.c main.c
  group Atmel Files/drivers/cortex-a
    AtmelFiles/drivers/cortex-a/: cortexa5_interrupts.c cortexa5_interrupts.h cp15.c cp15.h cp15_asm_iar.s cp15_pmu.c cp15_pmu.h cpsr.h cpsr_iar.s Makefile.inc mmu.c mmu.h
  group Atmel Files/drivers/misc
    AtmelFiles/drivers/misc/: led.c led.h
  group Atmel Files/drivers/peripherals
    AtmelFiles/drivers/peripherals/: aic.c aic.h flexcom.c flexcom.h l2cc.c l2cc.h matrix.c matrix.h pio.h pio4.c pio4.h pit.c pit.h pmc.c pmc.h tc.c tc.h twi.h twid.h wdt.c wdt.h xdmac.h xdmad.h
  group Atmel Files/drivers/power
    AtmelFiles/drivers/power/: act8945a.h
  group Atmel Files/target
    AtmelFiles/target/sama5d2/: board.h board_lowlevel.c board_lowlevel.h board_memories.h board_sama5d2-ptc-engi.h board_sama5d2-vb-bga196.h board_sama5d2-vb-bga289.h board_sama5d2-xplained-proto.h board_sama5d2-xplained.h chip.c chip.h chip_pins.h sama5d21.h sama5d22.h sama5d23.h sama5d24.h sama5d26.h sama5d27.h sama5d28.h
  group Atmel Files/target/component
    AtmelFiles/target/sama5d2/component/: component_acc.h component_adc.h component_aes.h component_aesb.h component_aic.h component_aximx.h component_chipid.h component_classd.h component_flexcom.h component_gmac.h component_i2sc.h component_icm.h component_isc.h component_l2cc.h component_lcdc.h component_matrix.h component_mcan.h component_mpddrc.h component_pdmic.h component_pio.h component_pit.h component_pmc.h component_pwm.h component_qspi.h component_rstc.h component_rtc.h component_rxlp.h component_sckc.h component_sdmmc.h component_sfc.h component_sfr.h component_sfrbu.h component_sha.h component_shdwc.h component_smc.h component_spi.h component_ssc.h component_tc.h component_tdes.h component_trng.h component_twihs.h component_uart.h component_udphs.h component_wdt.h component_xdmac.h
  group Atmel Files/target/pio
    AtmelFiles/target/sama5d2/pio/: pio_sama5d21.h pio_sama5d22.h pio_sama5d23.h pio_sama5d24.h pio_sama5d26.h pio_sama5d27.h pio_sama5d28.h
  group Atmel Files/utils
    AtmelFiles/utils/: async.h compiler.h crc.h dbg_util.h font.h hamming.h intmath.h io.h lcd_color.h lcd_draw.h lcd_font.h mutex.h rand.h ring.h timer.h trace.h wav.h
  group Blinky Demo
    blinky_demo/: main_blinky.c
  group FreeRTOS Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS Source/portable
    ../../Source/portable/IAR/ARM_CA5_No_GIC/: port.c portASM.h portASM.s portmacro.h
  group FreeRTOS Source/portable/MemMang
    ../../Source/portable/MemMang/: heap_4.c
  group Full Demo
    Full_Demo/: IntQueueTimer.c main_full.c reg_test.S
  group Full Demo/Common Demo Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c IntQueue.c QueueOverwrite.c recmutex.c semtest.c TimerDemo.c
